# Keil uVision project Universal_Remote_Control_of_NEC_Protocal.uvproj, settings and files
target Universal_Remote_Control_of_NEC_Protocal (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Universal_Remote_Control_of_NEC_Protocal
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin "
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Library\CMSIS\Include;.\Library\Device\Nuvoton\NUC100Series\Include;.\Library\Nu-LB-NUC140\Include;.\Library\StdDriver\inc;.\Library;..\Keil;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
    ./Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
  group Library
    ./Library/StdDriver/src/: clk.c gpio.c pwm.c spi.c sys.c timer.c uart.c
  group User
    ./Library/Nu-LB-NUC140/Source/: Draw2D.c IrDA_NEC.c LCD.c SYS_init.c
    ./: main.c
